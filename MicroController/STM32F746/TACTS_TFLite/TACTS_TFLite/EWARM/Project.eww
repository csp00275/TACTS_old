<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TACTS_TFLite.ewp</path>
  </project>
  <batchBuild />
</workspace>
